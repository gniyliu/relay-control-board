# IAR project WirelessWaterControl.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207MB STM8S207MB
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: E:\esoft\深圳同为旭业舒总\Huawei UPS\src\Libraries\STM8S_StdPeriph_Driver\inc; E:\esoft\深圳同为旭业舒总\Huawei UPS\src\e_src; I:\esoft\深圳同为旭业舒总\Huawei UPS\src\Libraries\STM8S_StdPeriph_Driver\inc; I:\esoft\深圳同为旭业舒总\Huawei UPS\src\e_src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: WirelessWaterControl.hex
  ILINK.IlinkOutputFile: WirelessWaterControl.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group e_src
    e_src/: e_main.c e_stm8s_conf.h e_stm8s_it.c e_stm8s_it.h
  group library
    Libraries/STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_spi.c stm8s_tim4.c stm8s_uart3.c
